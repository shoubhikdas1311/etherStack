# Keil uVision project SD_enet.uvprojx, settings and files
target Target 1 (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: MK60DN512xxx10 NXP
  pack: Keil.Kinetis_K60_DFP.1.5.0
  cpu: IRAM(0x20000000,0x00010000) IRAM2(0x1FFF0000,0x00010000) IROM(0x00000000,0x00080000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: SD_enet
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  group Source Group 1
    ./: main.c main.h
  group Drivers
    ./Drivers/: MK60N512.h SD_ADC.c SD_ADC.h SD_Clk.c SD_Clk.h SD_DAC.c SD_DAC.h SD_Delay.c SD_Delay.h SD_ENET.c SD_ENET.h SD_ETH.c SD_ETH.h SD_GPIO.c SD_GPIO.h SD_PIT.c SD_UART.c SD_UART.h SD_WDOG.c SD_WDOG.h Sys.c Sys.h ETH_PHY.h ETH.c ETH.h packet_Handler.c packet_Handler.h
  group common
    ./common/: arm_cm4.c arm_cm4.h common.h io.c io.h printf.c stdlib.c stdlib.h uif.c uif.h
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.0
